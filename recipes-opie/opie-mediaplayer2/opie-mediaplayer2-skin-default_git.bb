SKINNAME = "default"
require opie-mediaplayer2-skin.inc

PV = "${OPIE_GIT_PV}"
PR = "r5"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=pics"

