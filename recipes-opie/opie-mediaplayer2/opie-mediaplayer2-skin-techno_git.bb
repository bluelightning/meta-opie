SKINNAME = "techno"
require opie-mediaplayer2-skin.inc

inherit opie_git
PR = "r4"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=pics;name=first"

