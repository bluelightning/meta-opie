require ${PN}.inc

inherit opie_git
PR = "r8"
SRC_URI = "${OPIE_GIT};protocol=git;subpath=pics;name=first"
