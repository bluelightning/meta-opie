require ${PN}.inc

inherit opie_git
PR = "r3"

SRC_URI = "${OPIE_GIT};protocol=git;subpath=core/multimedia/opieplayer;name=first "
