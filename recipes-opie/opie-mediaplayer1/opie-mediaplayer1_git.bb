require ${PN}.inc

PV = "${OPIE_GIT_PV}0-${OPIE_SRCREV}"

